<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\KSDK2_MCIMXRT1052.ewp</path>
    </project>
    <batchBuild />
</workspace>
