# IAR project Backup of KSDK2_MCIMXRT1052.ewp, settings and files
configuration DEBUG_RAM (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx5A NXP MIMXRT1052xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1052DVL6B
  ICCARM.CCIncludePath2: ..\App; ..\App\testbench; ..\Board; ..\Drivers; ..\Drivers\Camera; ..\Drivers\Display; ..\Library; ..\Library\CMSIS; ..\Library\CMSIS\DSP_Lib; ..\Library\CMSIS\Include; ..\Library\CMSIS\Math; ..\Library\MCUXpressoSDK; ..\Library\MCUXpressoSDK\drivers; ..\Library\MCUXpressoSDK\startup; ..\Library\MCUXpressoSDK\utilities; ..\Library\MCUXpressoSDK\utilities\io; ..\Library\MCUXpressoSDK\utilities\log; ..\Library\MCUXpressoSDK\utilities\str; ..\Middleware; ..\SEGGER\RTT; ..\Xip
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DEBUG_QSPIFlash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1052DVL6B; XIP_EXTERNAL_FLASH=1
  OBJCOPY.OOCOutputFile: KSDK2_MCIMXRT1052.srec
  ILINK.IlinkKeepSymbols: image_vector_table; boot_data; dcd_data
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor.icf
configuration DEBUG_SDRAM (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1052DVL6B; USE_EXTERNAL_SDRAM=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_DCD_ENABLE=0; SKIP_SYSCLK_INIT
  OBJCOPY.OOCOutputFile: KSDK2_MCIMXRT1052.srec
  ILINK.IlinkKeepSymbols: xip_config; image_vector_table; boot_data; dcd_data
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_sdram.icf
  group App
    ../App/: appinc.h main.c
  group App/testbench
    ../App/testbench/: bsp_sdram.c bsp_sdram.h
  group Board
    ../Board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group Drivers/Camera
    ../Drivers/Camera/: ALEX_I2C&&SCCB.c ALEX_I2C&&SCCB.h ALEX_MT9V034.c ALEX_MT9V034.h ALEX_MT9V034_REG.h drv_camera.c drv_camera.h drv_camera_device.c drv_camera_device.h fsl_csi_camera_adapter.c fsl_csi_camera_adapter.h
  group Drivers/Camera/csi_common
    ../Drivers/Camera/: fsl_camera.h fsl_camera_device.h fsl_camera_receiver.h fsl_video_common.h
  group Drivers/Display
    ../Drivers/Display/: drv_display.c drv_display.h HX8369A.c HX8369A.h
  group Library/CMSIS/Include
    ../Library/CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_compiler.h cmsis_version.h core_cm7.h mpu_armv7.h
  group Library/MCUXpressoSDK
    ../Library/MCUXpressoSDK/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h
  group Library/MCUXpressoSDK/drivers
    ../Library/MCUXpressoSDK/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_csi.c fsl_csi.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_elcdif.c fsl_elcdif.h fsl_flexspi.c fsl_flexspi.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_pxp.c fsl_pxp.h fsl_semc.c fsl_semc.h
  group Library/MCUXpressoSDK/startup
    ../Library/MCUXpressoSDK/startup/: startup_MIMXRT1052.s system_MIMXRT1052.c system_MIMXRT1052.h
  group Library/MCUXpressoSDK/utilities
    ../Library/MCUXpressoSDK/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group Library/MCUXpressoSDK/utilities/io
    ../Library/MCUXpressoSDK/utilities/io/: fsl_io.c fsl_io.h
  group Library/MCUXpressoSDK/utilities/log
    ../Library/MCUXpressoSDK/utilities/log/: fsl_log.c fsl_log.h
  group SEGGER/RTT
    ../SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Xip
    ../Xip/: external_flash_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h xip_config.c
